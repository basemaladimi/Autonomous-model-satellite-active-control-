/ {
    aliases {
        my-led = &myled0;
    };

    leds {
        compatible = "gpio-leds";
        myled0: d13 {
            gpios = <&gpio0 13 GPIO_ACTIVE_HIGH>;
        };
    };
};